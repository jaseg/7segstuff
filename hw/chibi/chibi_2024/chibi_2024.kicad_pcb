# Repository jaseg/7segstuff

File README.rst:

Megumin LED display
===================

This repository contains schematics, firmware, host controller code and board
layouts for driving of hundreds of 7-segment displays. The firmware and some
basic host software may be found in the fw directory. The hardware design files
may be found in the hw directory.

This system uses a somewhat involved LED modulation technique. For details on
that have a look at the README.rst in the fw directory as well as the
well-documented code in fw/display.c.

## KiCad design hw/chibi/chibi_2024/chibi_2024.kicad_pcb

Board: 2 copper layers, 100.0 x 78.0 mm, 77 parts (8 on the bottom side), 89 nets.

Parts:
C1, C2, C4, C5, C6, C7, C8, C9: 100n; C_0603_HandSoldering
C3, C19: 1000u; C_Radial_D10_L20_P5
C10: 47u; c_elec_5x5.8
C11: 10n; C_0603_HandSoldering
C12, C13: 22p; C_0603_HandSoldering
D1: 6.4V 1.3W; D3
D7: ID; LED_0603
D8: ERROR; LED_0603
D9: COMM; LED_0603
D10, D11, D12, D13, D14, D15, D16, D17: 7seg_4digit_cc; 7seg_4digit_cc_modified
F1: 2.5A MT; Fuseholder5x20_horiz_open_universal_Type-III
P1, P1#2: VIN; m3_pillar
P3, P3#2: GND; m3_pillar
P4: CONN_02X03; Socket_Strip_Straight_2x03
P5: SWD; Socket_Strip_Straight_1x04
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: AO3415A; SOT-23_Handsoldering
Q14: Q_PNP_BEC; SOT-23_Handsoldering
Q15, Q16: Q_NPN_BEC; SOT-23_Handsoldering
R3: 47k; R_0603_HandSoldering
R4, R33, R34: 100k; R_0603_HandSoldering
R5: 10k; R_0603_HandSoldering
R35, R37: 100; R_0603_HandSoldering
R36: 140; R_0603_HandSoldering
R38, R39, R40, R41: R; R_0603_HandSoldering
R44: 1k; R_0603_HandSoldering
SW2: RESET; SW_SPST_FSMSM
U1: LD1117S33CTR; SOT-223
U2: SP3485CN; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: STM32F030F4Px; TSSOP-20_4.4x6.5mm_Pitch0.65mm
U5, U7: 74HC595_mine; SOIC-16_3.9x9.9mm_Pitch1.27mm
U8, U9: MBI5026; SSOP24-1.0-nosilk
U10: 74HCT125; SOIC-14_3.9x8.7mm_Pitch1.27mm
Y1: 25M; CRYSTAL-SMD-5X3
svg2mod: G***; label_fuse_04
svg2mod#2, svg2mod#8: G***; label_plus_04
svg2mod#3, svg2mod#4, svg2mod#9: G***; label_gnd_04
svg2mod#5: G***; label_comm_04
svg2mod#6: G***; label_error_04
svg2mod#7: G***; label_id_04
svg2mod#10: G***; label_data_04

Connections:
+3V3: C1.2, C5.2, C6.2, C9.2, C10.1, P5.4, R3.1, R5.2, U1.2, U1.4, U2.8, U3.5, U3.16, U5.10, U5.16
+5V: C2.2, C4.2, C7.2, C8.2, P4.2, P4.5, Q14.2, U1.3, U7.10, U7.16, U8.24, U9.24, U10.14
/AUX_STROBE: U3.18, U5.12, U7.12
/LED_COMM: R37.1, U5.2
/LED_ERROR: R36.1, U5.1
/LED_ID: R35.1, U5.3
/MOSI_C0: U3.13, U5.14, U10.9
/MOSI_C0_HV: U9.2, U10.8
/MOSI_C1_HV: U8.2, U9.22
/MOSI_C2: U5.9, U7.14
/RS485_A: P4.3, U2.6
/RS485_B: P4.4, U2.7
/RS485_DE: R4.1, U2.2, U2.3, U3.7
/RS485_RX: U2.1, U3.9
/RS485_TX: U2.4, U3.8
/RST: C11.1, R3.2, SW2.1, U3.4
/R_SET_0: Q15.3, R38.1, R40.1
/R_SET_1: Q16.3, R39.1, R41.1
/R_SET_CTRL0: R33.2, U5.6
/R_SET_CTRL1: R34.2, U5.7
/SCK: U3.11, U5.11, U7.11, U10.12
/SCK_HV: U8.3, U9.3, U10.11
/SEGC0: Q6.1, U7.15
/SEGC1: Q8.1, U7.1
/SEGC2: Q4.1, U7.2
/SEGC3: Q1.1, U7.3
/SEGC4: Q2.1, U7.4
/SEGC5: Q7.1, U7.5
/SEGC6: Q3.1, U7.6
/SEGC7: Q5.1, U7.7
/SEG_A_COM: D10.7, D11.7, D12.7, D13.7, D14.11, D15.11, D16.11, D17.11, Q8.2
/SEG_B_COM: D10.11, D11.11, D12.11, D13.11, D14.7, D15.7, D16.7, D17.7, Q3.2
/SEG_C_COM: D10.2, D11.2, D12.2, D13.2, D14.4, D15.4, D16.4, D17.4, Q1.2
/SEG_DP_COM: D10.3, D11.3, D12.3, D13.3, D14.3, D15.3, D16.3, D17.3, Q5.2
/SEG_D_COM: D10.4, D11.4, D12.4, D13.4, D14.2, D15.2, D16.2, D17.2, Q4.2
/SEG_E_COM: D10.5, D11.5, D12.5, D13.5, D14.1, D15.1, D16.1, D17.1, Q6.2
/SEG_F_COM: D10.10, D11.10, D12.10, D13.10, D14.10, D15.10, D16.10, D17.10, Q7.2
/SEG_G_COM: D10.1, D11.1, D12.1, D13.1, D14.5, D15.5, D16.5, D17.5, Q2.2
/STROBE: U3.17, U10.2
/STROBE_HV: U8.4, U9.4, U10.3
/SWCLK: P5.2, U3.20
/SWDIO: P5.1, U3.19
/VDD_PRE_FUSE: F1.1, P1.1, P1#2.1
/XT1: C12.2, U3.2, Y1.1
/XT2: C13.2, U3.3, Y1.3
/~OE: R5.1, U3.12, U10.5
/~OE_HV: R44.2, U10.6
/~OE_HV_CB: Q14.3, R44.1, U8.21, U9.21
GND: C1.1, C2.1, C3.2, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, C12.1, C13.1, C19.2, D1.2, D7.1, D8.1, D9.1, P3.1, P3#2.1, P4.1, P4.6, P5.3, Q15.2, Q16.2, R4.2, SW2.2, U1.1, U2.5, U3.1, U3.15, U5.8, U5.13, U7.8, U7.13, U8.1, U9.1, U10.1, U10.4, U10.7, U10.10, U10.13
unnamed: D7.2, R35.2
unnamed: D8.2, R36.2
unnamed: D9.2, R37.2
unnamed: D10.6, U8.8
unnamed: D10.8, U8.7
unnamed: D10.9, U8.6
unnamed: D10.12, U8.5
unnamed: D11.6, U8.12
unnamed: D11.8, U8.11
unnamed: D11.9, U8.10
unnamed: D11.12, U8.9
unnamed: D12.6, U8.13
unnamed: D12.8, U8.14
unnamed: D12.9, U8.15
unnamed: D12.12, U8.17
unnamed: D13.6, U8.20
unnamed: D13.8, U8.19
unnamed: D13.9, U8.18
unnamed: D13.12, U8.16
unnamed: D14.6, U9.5
unnamed: D14.8, U9.11
unnamed: D14.9, U9.8
unnamed: D14.12, U9.6
unnamed: D15.6, U9.9
unnamed: D15.8, U9.10
unnamed: D15.9, U9.12
unnamed: D15.12, U9.7
unnamed: D16.6, U9.13
unnamed: D16.8, U9.16
unnamed: D16.9, U9.15
unnamed: D16.12, U9.14
unnamed: D17.6, U9.17
unnamed: D17.8, U9.20
unnamed: D17.9, U9.19
unnamed: D17.12, U9.18
unnamed: Q15.1, R33.1
unnamed: Q16.1, R34.1
unnamed: R38.2, R39.2, U8.23
unnamed: R40.2, R41.2, U9.23
VDD: C3.1, C19.1, D1.1, F1.2, Q1.3, Q2.3, Q3.3, Q4.3, Q5.3, Q6.3, Q7.3, Q8.3

## KiCad design hw/chibi/layouttest/chibi_2024.kicad_pcb

Parts:
C1, C2, C4, C5, C6, C7, C8, C9, C20: 100n; C_0603_HandSoldering
C3, C19: 1000u; C_Radial_D10_L20_P5
C10: 47u; c_elec_5x5.8
C11: 10n; C_0603_HandSoldering
C12, C13: 22p; C_0603_HandSoldering
D1: 6.4V 1.3W; D3
D2, D3, D4: D_Small; MiniMELF_Standard
D7: ID; LED_0603
D8: ERROR; LED_0603
D9: COMM; LED_0603
F1: 2.5A MT; Fuseholder5x20_horiz_open_inline_Type-I
JP1: rpos; solder_jumper_3mm
JP2: rneg; solder_jumper_3mm
JP3: lpos; solder_jumper_3mm
JP4: lneg; solder_jumper_3mm
P1, P2, P3, P6: SUP; m3_pillar
P4: CONN_02X03; Socket_Strip_Straight_2x03
P5: SWD; Socket_Strip_Straight_1x04
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: AO3415A; SOT-23_Handsoldering
Q14: Q_PNP_BEC; SOT-23_Handsoldering
Q15, Q16: Q_NPN_BEC; SOT-23_Handsoldering
R1, R3, R20, R25, R29: 47k; R_0603_HandSoldering
R4, R22, R32, R33, R34: 100k; R_0603_HandSoldering
R5, R19, R24: 10k; R_0603_HandSoldering
R21, R23: 470k; R_0603_HandSoldering
R35, R37: 100; R_0603_HandSoldering
R36: 140; R_0603_HandSoldering
R44: 1k; R_0603_HandSoldering
SW2: RESET; SW_SPST_FSMSM
U1: LD1117S33CTR; SOT-223
U2: SP3485CN; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: STM32F030F4Px; TSSOP-20_4.4x6.5mm_Pitch0.65mm
U5, U7: 74HC595_mine; SOIC-16_3.9x9.9mm_Pitch1.27mm
U6: LM393; SOIC-8_3.9x4.9mm_Pitch1.27mm
U10: 74HCT125; SOIC-14_3.9x8.7mm_Pitch1.27mm
Y1: 25M; CRYSTAL-SMD-5X3

Connections:
+3V3: C1.2, C5.2, C6.2, C9.2, C10.1, P5.4, R3.1, R5.2, U1.2 (VO), U2.8 (VCC), U3.5 (VDDA), U3.16 (VDD), U5.10 (~MR), U5.16 (VCC)
+5V: C2.2, C3.1, C4.2, C7.2, C8.2, C19.1, D1.1 (K), F1.1, P4.2, P4.5, Q1.3 (D), Q2.3 (D), Q3.3 (D), Q4.3 (D), Q5.3 (D), Q6.3 (D), Q7.3 (D), Q8.3 (D), Q14.2 (E), R20.1, R22.2, R25.2, U1.3 (VI), U6.8 (V+), U7.10 (~MR), U7.16 (VCC), U10.14 (VCC); also elsewhere on the board
/AUX_STROBE: U3.18 (I2C1_SDA/TIM17_BKIN/TIM1_CH3/USART1_RX/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), U5.12 (STCP), U7.12 (STCP)
/LED_COMM: R37.1, U5.2 (Q2)
/LED_ERROR: R36.1, U5.1 (Q1)
/LED_ID: R35.1, U5.3 (Q3)
/MOSI_C0: U3.13 (ADC_IN7/SPI1_MOSI/TIM14_CH1/TIM17_CH1/T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), U5.14 (DS), U10.9 (I2)
/MOSI_C0_HV: U10.8 (Q2); also elsewhere on the board
/MOSI_C2: U5.9 (Q7S), U7.14 (DS)
/RS485_A: P4.3, U2.6 (A)
/RS485_B: P4.4, U2.7 (B)
/RS485_DE: R4.1, U2.2 (~RE~), U2.3 (DE), U3.7 (ADC_IN1/USART1_DE/USART1_RTS/PA1)
/RS485_RX: U2.1 (RO), U3.9 (ADC_IN3/USART1_RX/PA3)
/RS485_TX: U2.4 (DI), U3.8 (ADC_IN2/USART1_TX/PA2)
/RST: C11.1, D2.2 (A), R3.2, SW2.1, U3.4 (NRST)
/R_SET_CTRL0: R33.2, U5.6 (Q6)
/R_SET_CTRL1: R34.2, U5.7 (Q7)
/SCK: U3.11 (ADC_IN5/SPI1_SCK/PA5), U5.11 (SHCP), U7.11 (SHCP), U10.12 (I3)
/SCK_HV: U10.11 (Q3); also elsewhere on the board
/SEG_A_COM: Q7.2 (S); also elsewhere on the board
/SEG_A_CTRL: Q7.1 (G), U7.7 (Q7)
/SEG_B_COM: Q3.2 (S); also elsewhere on the board
/SEG_B_CTRL: Q3.1 (G), U7.6 (Q6)
/SEG_C_COM: Q1.2 (S); also elsewhere on the board
/SEG_C_CTRL: Q1.1 (G), U7.1 (Q1)
/SEG_DP_COM: Q4.2 (S); also elsewhere on the board
/SEG_DP_CTRL: Q4.1 (G), R32.2, U7.2 (Q2)
/SEG_D_COM: Q6.2 (S); also elsewhere on the board
/SEG_D_CTRL: Q6.1 (G), U7.3 (Q3)
/SEG_E_COM: Q8.2 (S); also elsewhere on the board
/SEG_E_CTRL: Q8.1 (G), U7.5 (Q5)
/SEG_F_COM: Q5.2 (S); also elsewhere on the board
/SEG_F_CTRL: Q5.1 (G), U7.4 (Q4)
/SEG_G_COM: Q2.2 (S); also elsewhere on the board
/SEG_G_CTLR: Q2.1 (G), U7.15 (Q0)
/STROBE: U3.17 (I2C1_SCL/TIM1_CH2/USART1_TX/PA9), U10.2 (I0)
/STROBE_HV: U10.3 (Q0); also elsewhere on the board
/SWCLK: P5.2, U3.20 (SYS_SWCLK/USART1_TX/PA14)
/SWDIO: P5.1, U3.19 (IR_OUT/SYS_SWDIO/PA13)
/WD_COMP1: C20.1, R32.1, U6.6 (_)
/WD_REF1: R23.1, R25.1, R29.2, U6.3 (+)
/WD_REF2: R21.1, R22.1, R24.2, U6.5 (+)
/XT1: C12.2, U3.2 (PF0/RCC_OSC_IN), Y1.1
/XT2: C13.2, U3.3 (PF1/RCC_OSC_OUT), Y1.3
/in_left: JP1.1, JP2.1, P1.1, P2.1
/in_right: JP3.1, JP4.1, P3.1, P6.1
/mux_mod_left/R_SET_0: Q15.3 (C); also elsewhere on the board
/mux_mod_left/R_SET_1: Q16.3 (C); also elsewhere on the board
/~OE: R5.1, U3.12 (ADC_IN6/SPI1_MISO/TIM16_CH1/TIM1_BKIN/T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), U10.5 (I1)
/~OE_HV: R44.2, U10.6 (Q1)
/~OE_HV_CB: Q14.3 (C), R44.1; also elsewhere on the board
/~WD_RST: D2.1 (K), D3.2 (A), D4.2 (A), R19.2, R20.2
/~WD_RST1: D3.1 (K), R23.2, U6.1
/~WD_RST2: D4.1 (K), R21.2, U6.7
GND: C1.1, C2.1, C3.2, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, C12.1, C13.1, C19.2, C20.2, D1.2 (A), D7.1, D8.1, D9.1, JP2.2, JP4.2, P4.1, P4.6, P5.3, Q15.2 (E), Q16.2 (E), R1.1, R4.2, R24.1, R29.1, SW2.2, U1.1 (GND), U2.5 (GND), U3.1 (BOOT0), U3.15 (VSS), U5.8 (GND), U5.13 (~OE), U6.4 (V-), U7.8 (GND), U7.13 (~OE), U10.1 (~OE0), U10.4 (~OE1), U10.7 (GND), U10.10 (~OE2), U10.13 (~OE3); also elsewhere on the board
unnamed: F1.2, JP1.2, JP3.2
unnamed: Q14.1 (B), R19.1
unnamed: Q15.1 (B), R33.1
unnamed: Q16.1 (B), R34.1
unnamed: R1.2, U6.2 (_)

Notes on the sheet:
optional
Chibi 2x4x(4x7)seg controller
Each mux module contains 4 four-digit 7-segment displays
Vin trimmed to lowest sensible value to reduce power dissipation. Vin ~~= Vdrop + Vfw + Vfet + Vshunt + Vwiring = 1.0 + 1.85 + 0.25 + 0.25 + 0.25 = 3.6V
Status leds

Parts:
D14, D15, D16, D17: 7seg_4digit_cc; 7seg_4digit_cc_modified
R38, R41: R; R_0603_HandSoldering
U9: MBI5026; SSOP24-1.0-nosilk

Connections:
+5V: U9.24 (VDD); also elsewhere on the board
/MOSI_C0_HV: U9.2 (SDI); also elsewhere on the board
/MOSI_C1_HV: U9.22 (SDO); also elsewhere on the board
/SCK_HV: U9.3 (CLK); also elsewhere on the board
/SEG_A_COM: D14.11 (A), D15.11 (A), D16.11 (A), D17.11 (A); also elsewhere on the board
/SEG_B_COM: D14.7 (B), D15.7 (B), D16.7 (B), D17.7 (B); also elsewhere on the board
/SEG_C_COM: D14.4 (C), D15.4 (C), D16.4 (C), D17.4 (C); also elsewhere on the board
/SEG_DP_COM: D14.3 (DP), D15.3 (DP), D16.3 (DP), D17.3 (DP); also elsewhere on the board
/SEG_D_COM: D14.2 (D), D15.2 (D), D16.2 (D), D17.2 (D); also elsewhere on the board
/SEG_E_COM: D14.1 (E), D15.1 (E), D16.1 (E), D17.1 (E); also elsewhere on the board
/SEG_F_COM: D14.10 (F), D15.10 (F), D16.10 (F), D17.10 (F); also elsewhere on the board
/SEG_G_COM: D14.5 (G), D15.5 (G), D16.5 (G), D17.5 (G); also elsewhere on the board
/STROBE_HV: U9.4 (LE); also elsewhere on the board
/mux_mod_left/R_SET_0: R38.1; also elsewhere on the board
/mux_mod_left/R_SET_1: R41.1; also elsewhere on the board
/~OE_HV_CB: U9.21 (~OE); also elsewhere on the board
GND: U9.1 (GND); also elsewhere on the board
unnamed: D14.6 (CC4), U9.20 (OUT15)
unnamed: D14.8 (CC3), U9.19 (OUT14)
unnamed: D14.9 (CC2), U9.18 (OUT13)
unnamed: D14.12 (CC1), U9.17 (OUT12)
unnamed: D15.6 (CC4), U9.16 (OUT11)
unnamed: D15.8 (CC3), U9.15 (OUT10)
unnamed: D15.9 (CC2), U9.14 (OUT9)
unnamed: D15.12 (CC1), U9.13 (OUT8)
unnamed: D16.6 (CC4), U9.12 (OUT7)
unnamed: D16.8 (CC3), U9.11 (OUT6)
unnamed: D16.9 (CC2), U9.10 (OUT5)
unnamed: D16.12 (CC1), U9.9 (OUT4)
unnamed: D17.6 (CC4), U9.8 (OUT3)
unnamed: D17.8 (CC3), U9.7 (OUT2)
unnamed: D17.9 (CC2), U9.6 (OUT1)
unnamed: D17.12 (CC1), U9.5 (OUT0)

Parts of its further copies:
D10, D11, D12, D13: 7seg_4digit_cc; 7seg_4digit_cc_modified
R39, R40: R; R_0603_HandSoldering
U8: MBI5026; SSOP24-1.0-nosilk

Connections of its further copies:
+5V: U8.24 (VDD); also elsewhere on the board
/MOSI_C1_HV: U8.2 (SDI); also elsewhere on the board
/SCK_HV: U8.3 (CLK); also elsewhere on the board
/SEG_A_COM: D10.11 (A), D11.11 (A), D12.11 (A), D13.11 (A); also elsewhere on the board
/SEG_B_COM: D10.7 (B), D11.7 (B), D12.7 (B), D13.7 (B); also elsewhere on the board
/SEG_C_COM: D10.4 (C), D11.4 (C), D12.4 (C), D13.4 (C); also elsewhere on the board
/SEG_DP_COM: D10.3 (DP), D11.3 (DP), D12.3 (DP), D13.3 (DP); also elsewhere on the board
/SEG_D_COM: D10.2 (D), D11.2 (D), D12.2 (D), D13.2 (D); also elsewhere on the board
/SEG_E_COM: D10.1 (E), D11.1 (E), D12.1 (E), D13.1 (E); also elsewhere on the board
/SEG_F_COM: D10.10 (F), D11.10 (F), D12.10 (F), D13.10 (F); also elsewhere on the board
/SEG_G_COM: D10.5 (G), D11.5 (G), D12.5 (G), D13.5 (G); also elsewhere on the board
/STROBE_HV: U8.4 (LE); also elsewhere on the board
/mux_mod_left/R_SET_0: R40.1; also elsewhere on the board
/mux_mod_left/R_SET_1: R39.1; also elsewhere on the board
/mux_mod_right/SDO: U8.22 (SDO)
/~OE_HV_CB: U8.21 (~OE); also elsewhere on the board
GND: U8.1 (GND); also elsewhere on the board
unnamed: D10.6 (CC4), U8.20 (OUT15)
unnamed: D10.8 (CC3), U8.19 (OUT14)
unnamed: D10.9 (CC2), U8.18 (OUT13)
unnamed: D10.12 (CC1), U8.17 (OUT12)
unnamed: D11.6 (CC4), U8.16 (OUT11)
unnamed: D11.8 (CC3), U8.15 (OUT10)
unnamed: D11.9 (CC2), U8.14 (OUT9)
unnamed: D11.12 (CC1), U8.13 (OUT8)
unnamed: D12.6 (CC4), U8.12 (OUT7)
unnamed: D12.8 (CC3), U8.11 (OUT6)
unnamed: D12.9 (CC2), U8.10 (OUT5)
unnamed: D12.12 (CC1), U8.9 (OUT4)
unnamed: D13.6 (CC4), U8.8 (OUT3)
unnamed: D13.8 (CC3), U8.7 (OUT2)
unnamed: D13.9 (CC2), U8.6 (OUT1)
unnamed: D13.12 (CC1), U8.5 (OUT0)

Notes on the sheet:
Single multiplexing unit
4 displays, 1 driver

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
Board: 2 copper layers, 100.0 x 78.0 mm, 97 parts (9 on the bottom side), 95 nets.

Other parts of the board:
svg2mod: G***; megumin
svg2mod#2: G***; label_fuse_04
svg2mod#3, svg2mod#9: G***; label_plus_04
svg2mod#4, svg2mod#5, svg2mod#10: G***; label_gnd_04
svg2mod#6: G***; label_comm_04
svg2mod#7: G***; label_error_04
svg2mod#8: G***; label_id_04
svg2mod#11: G***; label_data_04

## Code that names these connections

File fw/main.c:

/* Megumin LED display firmware
 * Copyright (C) 2018 Sebastian Götte <code@jaseg.net>
 * 
 * This program is free software: you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation, either version 3 of the License, or
 * (at your option) any later version.
 * 
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 * 
 * You should have received a copy of the GNU General Public License
 * along with this program.  If not, see <http://www.gnu.org/licenses/>.
 */

#include "global.h"

#include "display.h"
#include "serial.h"
#include "led.h"
#include "adc.h"

volatile unsigned int sys_time = 0;
volatile unsigned int sys_time_seconds = 0;

int main(void) {
    RCC->CR |= RCC_CR_HSEON;
    while (!(RCC->CR&RCC_CR_HSERDY));
    RCC->CFGR &= ~RCC_CFGR_PLLMUL_Msk & ~RCC_CFGR_SW_Msk & ~RCC_CFGR_PPRE_Msk & ~RCC_CFGR_HPRE_Msk;
    RCC->CFGR |= (2<<RCC_CFGR_PLLMUL_Pos) | RCC_CFGR_PLLSRC_HSE_PREDIV; /* PLL x4 -> 50.0MHz */
    RCC->CFGR2 &= ~RCC_CFGR2_PREDIV_Msk;
    RCC->CFGR2 |= RCC_CFGR2_PREDIV_DIV2; /* prediv :2 -> 12.5MHz */
    RCC->CR |= RCC_CR_PLLON;
    while (!(RCC->CR&RCC_CR_PLLRDY));
    RCC->CFGR |= (2<<RCC_CFGR_SW_Pos);
    SystemCoreClockUpdate();

    /* Turn on lots of neat things */
    RCC->AHBENR  |= RCC_AHBENR_GPIOAEN | RCC_AHBENR_DMAEN | RCC_AHBENR_CRCEN | RCC_AHBENR_FLITFEN;
    RCC->APB2ENR |= RCC_APB2ENR_SPI1EN | RCC_APB2ENR_USART1EN | RCC_APB2ENR_SYSCFGEN | RCC_APB2ENR_ADCEN | RCC_APB2ENR_DBGMCUEN | RCC_APB2ENR_TIM1EN;
    RCC->APB1ENR |= RCC_APB1ENR_TIM3EN;

    GPIOA->MODER |=
          (1<<GPIO_MODER_MODER0_Pos)  /* PA0  - Debug */
        | (2<<GPIO_MODER_MODER1_Pos)  /* PA1  - RS485 DE */
        | (2<<GPIO_MODER_MODER2_Pos)  /* PA2  - RS485 TX */
        | (2<<GPIO_MODER_MODER3_Pos)  /* PA3  - RS485 RX */
        | (1<<GPIO_MODER_MODER4_Pos)  /* PA4  - Debug */
        | (2<<GPIO_MODER_MODER5_Pos)  /* PA5  - SCLK */
        | (2<<GPIO_MODER_MODER6_Pos)  /* PA6  - LED !OE */
        | (2<<GPIO_MODER_MODER7_Pos)  /* PA7  - MOSI */
        | (2<<GPIO_MODER_MODER9_Pos)  /* PA9  - LED strobe */
        | (1<<GPIO_MODER_MODER10_Pos);/* PA10 - Auxiliary strobe */

    /* Set shift register IO GPIO output speed */
    GPIOA->OSPEEDR |=
          (2<<GPIO_OSPEEDR_OSPEEDR0_Pos)   /* Debug */
        | (2<<GPIO_OSPEEDR_OSPEEDR1_Pos)   /* RS485 DE */
        | (2<<GPIO_OSPEEDR_OSPEEDR2_Pos)   /* TX */
        | (2<<GPIO_OSPEEDR_OSPEEDR3_Pos)   /* RX */
        | (2<<GPIO_OSPEEDR_OSPEEDR4_Pos)   /* Debug */
        | (2<<GPIO_OSPEEDR_OSPEEDR5_Pos)   /* SCLK */
        | (2<<GPIO_OSPEEDR_OSPEEDR6_Pos)   /* LED !OE   */
        | (2<<GPIO_OSPEEDR_OSPEEDR7_Pos)   /* MOSI */
        | (2<<GPIO_OSPEEDR_OSPEEDR9_Pos)   /* LED strobe */
        | (2<<GPIO_OSPEEDR_OSPEEDR10_Pos); /* Auxiliary strobe */

    GPIOA->AFR[0] |=
          (1<<GPIO_AFRL_AFRL1_Pos)   /* USART1_RTS (DE) */
        | (1<<GPIO_AFRL_AFRL2_Pos)   /* USART1_TX */
        | (1<<GPIO_AFRL_AFRL3_Pos)   /* USART1_RX */
        | (0<<GPIO_AFRL_AFRL5_Pos)   /* SPI1_SCK */
        | (1<<GPIO_AFRL_AFRL6_Pos)   /* TIM3_CH1 */
        | (0<<GPIO_AFRL_AFRL7_Pos);  /* SPI1_MOSI */
    GPIOA->AFR[1] |=
          (2<<GPIO_AFRH_AFRH1_Pos);  /* TIM1_CH2 */

    GPIOA->PUPDR |=
          (2<<GPIO_PUPDR_PUPDR1_Pos)  /* RS485 DE: Pulldown */
        | (1<<GPIO_PUPDR_PUPDR2_Pos)  /* TX */
        | (1<<GPIO_PUPDR_PUPDR3_Pos); /* RX */

    display_init();
    SysTick_Config(SystemCoreClock/1000); /* 1ms interval */
    serial_init();
    adc_init();

    while (42) {
        led_task();

        /* Process pending buffer transfer */
        if (fb_op == FB_FORMAT) {
            transpose_data(rx_buf.byte_data, write_fb);
            fb_op = FB_UPDATE;
        }
    }
}

void NMI_Handler(void) {
}

void HardFault_Handler(void) __attribute__((naked));
void HardFault_Handler() {
    asm volatile ("bkpt");
}

void SVC_Handler(void) {
}

void PendSV_Handler(void) {
}

void SysTick_Handler(void) {
    static int n = 0;
    sys_time++;
    if (n++ == 1000) {
        n = 0;
        sys_time_seconds++;
    }
}

File fw/display.c (part):

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volatile struct framebuf *read_fb=fb+0, *write_fb=fb+1;

/* Auxiliary shift register values */
#define LED_COMM     0x0001
#define LED_ERROR    0x0002
#define LED_ID       0x0004
#define SR_ILED_HIGH 0x0080
#define SR_ILED_LOW  0x0040

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
## Commit log

2017-04-28 Added protection stuff
2017-04-29 Pre safety fixup
2017-05-02 Layout mostly done
2017-05-04 Design mostly done
2017-05-17 Release v0.2
2017-06-10 fw working commit
2017-06-11 Test program working
2017-06-12 Add resistor calculation script
2017-07-15 Schematic fixed up so far
2017-07-20 Second board revision
2017-07-20 Add missing firmware build files
2017-07-20 Final silk art positioning
2017-07-21 Second production run, v0.3
2017-08-13 Board rev 0.3 working
2017-08-14 Multiplexing is working
2017-08-15 Working on uart code
2017-08-15 Temporary for bit shuffling
2017-08-15 working commit
2017-08-15 Benchmark code
2017-08-22 Add profiling script
2017-08-23 Add transpose test
2017-08-23 Add cmsis export generator
2017-08-23 Comms working except for TIM3/SPI1 race
2017-08-23 Interrupt-driven SPI1 fundamentally working
2017-08-23 Serial protocol now working including CRC
2017-09-01 DMA channel assignments redone, basic protocol stuff working
2017-09-01 UART magic seems to be working now
2017-09-01 Add missing files
2017-09-01 Now with working source extraction from firmware
2017-09-02 Temperature/VCC ADC working
2017-09-06 Fixes for second prototype (v0.3)
2017-09-06 Fix up version label and one ground trace
2017-09-06 Fix up RS485/digital power label
2017-09-18 hw v0.4
2017-12-08 Basic UART working, but too slow
2017-12-09 Cycle timing is fixed again
2017-12-09 Fixed aux cycle
2017-12-09 Aux register loading further optimized
2017-12-09 Made all ISRs *fast* (<2.5us)
2017-12-09 UART and LEDs playing nicely
2017-12-09 Framing experiments
2017-12-09 Framing works now
2017-12-10 Add lots of doc and fix segment driving
2017-12-10 Rough ADC triggering works now
2017-12-10 ADC properly triggering now
2017-12-10 ADC temperature measurement works now
2017-12-10 Make comm and error LEDs useful
2017-12-10 Prettify and document AUX LED handling
2017-12-10 Add discovery and addressing mechanism
2017-12-10 Prettified the python side of things a bit
2017-12-10 Make status request work, fix uc-side cobs encoding bug
2018-01-05 Add some documentation
2018-01-05 Firmware directory reorganization
2018-01-05 Split project into individual source files and add license
2018-01-05 Add global README
2018-04-20 Small firmware foo
2020-04-11 Add local changes
